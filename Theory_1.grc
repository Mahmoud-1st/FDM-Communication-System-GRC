options:
  parameters:
    author: xmahm
    generate_options: qt_gui
    id: Theory_1
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: AM_BW
  id: variable
  parameters:
    value: 2*B
  states: {}
- name: AMstation
  id: variable
  parameters:
    value: '100000'
  states: {}
- name: Acarrier
  id: variable
  parameters:
    value: '1'
  states: {}
- name: B
  id: variable
  parameters:
    value: '20000'
  states: {}
- name: BW
  id: variable
  parameters:
    value: AM_BW
  states: {}
- name: FM_BW
  id: variable
  parameters:
    value: 2*B
  states: {}
- name: FMstation
  id: variable
  parameters:
    value: '150000'
  states: {}
- name: IF
  id: variable
  parameters:
    value: '25000'
  states: {}
- name: Max_Deviation
  id: variable
  parameters:
    value: '5000'
  states: {}
- name: Transition_Width
  id: variable
  parameters:
    value: '1800'
  states: {}
- name: Transition_Width_Low_freq
  id: variable
  parameters:
    value: '1000'
  states: {}
- name: frequency_offset
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '100'
    stop: '1000'
    value: '0'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '441000'
  states: {}
- name: station
  id: variable
  parameters:
    value: AMstation
  states: {}
- name: analog_fm_demod_cf_0
  id: analog_fm_demod_cf
  parameters:
    audio_decim: '1'
    audio_pass: BW
    audio_stop: BW+Transition_Width
    chan_rate: samp_rate
    deviation: Max_Deviation
    gain: '1.0'
    tau: '75e-6'
  states: {}
- name: analog_nbfm_tx_0
  id: analog_nbfm_tx
  parameters:
    audio_rate: samp_rate
    fh: '-1.0'
    max_dev: Max_Deviation
    quad_rate: samp_rate
    tau: '75e-6'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: Acarrier
    freq: '100000'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_sig_source_x_1
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: station+IF
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_sig_source_x_1_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: IF+frequency_offset
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: '44100'
  states: {state: disabled}
- name: audio_sink_1
  id: audio_sink
  parameters:
    samp_rate: '44100'
  states: {state: disabled}
- name: audio_sink_2
  id: audio_sink
  parameters:
    samp_rate: '44100'
  states: {}
- name: band_pass_filter_0
  id: band_pass_filter
  parameters:
    decim: '1'
    gain: '1'
    high_cutoff_freq: station+.5*BW
    low_cutoff_freq: station-.5*BW
    samp_rate: samp_rate
    type: fir_filter_fff
    width: Transition_Width
    win: window.WIN_HAMMING
  states: {}
- name: band_pass_filter_0_0
  id: band_pass_filter
  parameters:
    decim: '1'
    gain: '1'
    high_cutoff_freq: IF+.5*BW
    low_cutoff_freq: IF-.5*BW
    samp_rate: samp_rate
    type: fir_filter_fff
    width: Transition_Width_Low_freq
    win: window.WIN_HAMMING
  states: {}
- name: blocks_add_const_vxx_0
  id: blocks_add_const_vxx
  parameters:
    const: Acarrier
    type: float
  states: {}
- name: blocks_add_xx_1
  id: blocks_add_xx
  parameters:
    type: float
  states: {}
- name: blocks_complex_to_float_0
  id: blocks_complex_to_float
  parameters: {}
  states: {}
- name: blocks_freqshift_cc_0
  id: blocks_freqshift_cc
  parameters:
    freq: FMstation
    sample_rate: samp_rate
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '2'
    type: float
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_multiply_xx_1
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_multiply_xx_1_0
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: E:\2T\Communication Theory 1\Project\001.wav
    repeat: 'True'
  states: {state: disabled}
- name: blocks_wavfile_source_0_0
  id: blocks_wavfile_source
  parameters:
    file: E:\2T\Communication Theory 1\Project\kamhunt-run-130bpm-190419.wav
    repeat: 'True'
  states: {}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: IF+frequency_offset
    decim: '1'
    samp_rate: samp_rate
    taps: firdes.low_pass(1, samp_rate, BW, Transition_Width)
    type: fcf
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: .5*BW
    decim: '1'
    gain: '1'
    interp: '10'
    samp_rate: samp_rate
    type: fir_filter_fff
    width: Transition_Width_Low_freq
    win: window.WIN_HAMMING
  states: {}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '32768'
    name: '"FDM"'
    type: float
    update_time: '0.1'
  states: {}
- name: qtgui_freq_sink_x_0_0_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '32768'
    name: '"RF → Mixer"'
    type: float
    update_time: '0.1'
  states: {}
- name: qtgui_freq_sink_x_0_0_0_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '32768'
    name: '"Mixer → IF"'
    type: float
    update_time: '0.1'
  states: {}
- name: qtgui_freq_sink_x_0_0_0_1
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '32768'
    name: '"IF → baseband detector"'
    type: float
    update_time: '0.1'
  states: {}
- name: qtgui_freq_sink_x_0_0_0_1_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '32768'
    name: '"baseband detector → LPF"'
    type: float
    update_time: '0.1'
  states: {}
- name: qtgui_freq_sink_x_0_0_0_1_0_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '32768'
    name: '"AM out"'
    type: float
    update_time: '0.1'
    wintype: window.WIN_HANN
  states: {}
- name: qtgui_freq_sink_x_0_0_0_1_0_0_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '32768'
    name: '"FM out"'
    type: float
    update_time: '0.1'
    wintype: window.WIN_HAMMING
  states: {}
- name: qtgui_freq_sink_x_0_0_0_1_0_1
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '32768'
    name: '"LPF → AM out"'
    type: float
    update_time: '0.1'
  states: {}
- name: qtgui_freq_sink_x_0_1
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '32768'
    name: '"m(f)"'
    type: float
    update_time: '0.1'
  states: {}
- name: qtgui_time_sink_x_0_0_0
  id: qtgui_time_sink_x
  parameters:
    name: '"m(t)"'
    size: '44100'
    srate: samp_rate
    type: float
    update_time: '.1'
    ylabel: Amp
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '1'
    interp: '10'
    type: fff
  states: {}
- name: rational_resampler_xxx_0_0
  id: rational_resampler_xxx
  parameters:
    decim: '10'
    interp: '1'
    type: fff
  states: {}
- name: rational_resampler_xxx_0_0_0
  id: rational_resampler_xxx
  parameters:
    decim: '10'
    interp: '1'
    type: fff
  states: {}

connections:
- [analog_fm_demod_cf_0, '0', rational_resampler_xxx_0_0_0, '0']
- [analog_nbfm_tx_0, '0', blocks_freqshift_cc_0, '0']
- [analog_sig_source_x_0, '0', blocks_multiply_xx_0, '1']
- [analog_sig_source_x_1, '0', blocks_multiply_xx_1, '1']
- [analog_sig_source_x_1_0, '0', blocks_multiply_xx_1_0, '0']
- [band_pass_filter_0, '0', blocks_multiply_xx_1, '0']
- [band_pass_filter_0, '0', qtgui_freq_sink_x_0_0_0, '0']
- [band_pass_filter_0_0, '0', blocks_multiply_xx_1_0, '1']
- [band_pass_filter_0_0, '0', freq_xlating_fir_filter_xxx_0, '0']
- [band_pass_filter_0_0, '0', qtgui_freq_sink_x_0_0_0_1, '0']
- [blocks_add_const_vxx_0, '0', blocks_multiply_xx_0, '0']
- [blocks_add_xx_1, '0', band_pass_filter_0, '0']
- [blocks_add_xx_1, '0', qtgui_freq_sink_x_0_0, '0']
- [blocks_complex_to_float_0, '0', blocks_add_xx_1, '1']
- [blocks_freqshift_cc_0, '0', blocks_complex_to_float_0, '0']
- [blocks_multiply_const_vxx_0, '0', qtgui_freq_sink_x_0_0_0_1_0_1, '0']
- [blocks_multiply_const_vxx_0, '0', rational_resampler_xxx_0_0, '0']
- [blocks_multiply_xx_0, '0', blocks_add_xx_1, '0']
- [blocks_multiply_xx_1, '0', band_pass_filter_0_0, '0']
- [blocks_multiply_xx_1, '0', qtgui_freq_sink_x_0_0_0_0, '0']
- [blocks_multiply_xx_1_0, '0', low_pass_filter_0, '0']
- [blocks_multiply_xx_1_0, '0', qtgui_freq_sink_x_0_0_0_1_0, '0']
- [blocks_wavfile_source_0, '0', audio_sink_0, '0']
- [blocks_wavfile_source_0, '0', qtgui_freq_sink_x_0_1, '0']
- [blocks_wavfile_source_0, '0', qtgui_time_sink_x_0_0_0, '0']
- [blocks_wavfile_source_0, '0', rational_resampler_xxx_0, '0']
- [blocks_wavfile_source_0_0, '0', audio_sink_0, '0']
- [blocks_wavfile_source_0_0, '0', qtgui_freq_sink_x_0_1, '0']
- [blocks_wavfile_source_0_0, '0', qtgui_time_sink_x_0_0_0, '0']
- [blocks_wavfile_source_0_0, '0', rational_resampler_xxx_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', analog_fm_demod_cf_0, '0']
- [low_pass_filter_0, '0', blocks_multiply_const_vxx_0, '0']
- [rational_resampler_xxx_0, '0', analog_nbfm_tx_0, '0']
- [rational_resampler_xxx_0, '0', blocks_add_const_vxx_0, '0']
- [rational_resampler_xxx_0_0, '0', audio_sink_2, '0']
- [rational_resampler_xxx_0_0, '0', qtgui_freq_sink_x_0_0_0_1_0_0, '0']
- [rational_resampler_xxx_0_0_0, '0', audio_sink_1, '0']
- [rational_resampler_xxx_0_0_0, '0', qtgui_freq_sink_x_0_0_0_1_0_0_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
